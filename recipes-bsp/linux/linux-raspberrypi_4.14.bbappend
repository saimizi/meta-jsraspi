include recipes-ipcon/linux/ipcon-driver.inc
